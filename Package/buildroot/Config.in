## Package/buildroot/Config.in
```kconfig
config BR2_PACKAGE_IOPCCMD
	bool "iopccmd"
	select BR2_PACKAGE_LIBIOPCCMD_CLIENT
	help
	  IOPC message queue util.
```
